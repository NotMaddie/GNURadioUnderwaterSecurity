options:
  parameters:
    author: notma
    generate_options: qt_gui
    id: channel
    output_language: python
    title: Final Channel FSK
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '45.4545'
  states: {}
- name: centre
  id: variable
  parameters:
    value: '11440'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: delay
    rangeType: int
    start: '0'
    step: '10'
    stop: '200'
    value: '75'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '80'
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: '0.068'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '1056'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35,11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11440'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: '0.850'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.00001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-70'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: vco_offset
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '85'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: inp_amp
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1056'
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '500'
    samp_rate: samp_rate
    sensitivity: (2*math.pi* vco_max)/1
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    K: '0.8'
    LOS: 'True'
    N: '8'
    delays: (0.0,0.1,1.6)
    fDTs: 1.67/samp_rate
    mags: (1,0.99,0.98)
    ntaps: '8'
    seed: '0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nimport pmt\nimport os\n\nfrom cryptography.hazmat.primitives.ciphers.aead import AESGCM\n\ntextboxValue = \"\"\nkey = \"\"\nnonce = \"\"\n\nclass my_sync_block(gr.sync_block):\n    \"\"\"\n    reads input from a message port\n    outputs encrypted data using AES-GCM \n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name = \"AES-GCM Encryption\",\n            in_sig = None,\n            out_sig = [np.byte])\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('clear_input'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        global textboxValue\n        global key\n        global nonce\n        \n        message = pmt.symbol_to_string (msg)\n        data = bytes(message, 'ascii')\n        \n        key = AESGCM.generate_key(bit_length=128)\n        aesgcm = AESGCM(key)\n        nonce = os.urandom(12)\n        encryptText = aesgcm.encrypt(nonce, data, None)\n        textboxValue = encryptText\n                \n        textboxValue = str(textboxValue)\n        #print(textboxValue)\n        \n               \n\n    \n    def work(self, input_items, output_items):\n        global textboxValue\n        \n        # get length of string\n        _len = len(textboxValue)      \n        print(_len)\n        # store elements in output array   \n        if (_len > 0):\n            # terminate with LF\n            textboxValue += \"\\n\"\n            _len += 1\n            # store elements in output array\n            for x in range(_len):\n                output_items[0][x] = ord(textboxValue[x])\n            textboxValue = \"\"\n            self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))\n            return (_len)\n        else:\n            return (0)\n\n"
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: centre
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 1000, 400)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '200'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Multipath Noise
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Gauss Noise
  states: {}
- name: note_1
  id: note
  parameters:
    note: BER Estimation
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Data Encryption
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: BFSK Modulation
  states: {}
- name: note_1_2
  id: note
  parameters:
    note: BFSK Demodulation
  states: {}
- name: note_1_3
  id: note
  parameters:
    note: Signal Error
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    autoScale: 'False'
    fac_decimation: '10'
    fac_size: '512'
    sampRate: samp_rate
    useDB: 'False'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Input
    type: string
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: BER Estimation
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Receiver
    label2: Transmitter
    name: ''
    nconnections: '2'
    size: '16384'
    srate: samp_rate
    type: float
    update_time: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: Error Signal
    name: Signal Error
    size: '16384'
    srate: samp_rate
    type: float
    update_time: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: encrypt_data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fsk_out
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fsk_gauss_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: fsk_channel_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fsk_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: fsk_channel_out
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: fsk_gauss_out
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: encrypt_data
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_2, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_1, '0', fec_ber_bf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_throttle_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_1, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0_1, '0', virtual_sink_0_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_sub_xx_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repeat_0, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [channels_selective_fading_model_0, '0', qtgui_auto_correlator_sink_0, '0']
- [channels_selective_fading_model_0, '0', virtual_sink_2_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [digital_binary_slicer_fb_0, '0', fec_ber_bf_0, '1']
- [epy_block_0, '0', blocks_throttle_0_1, '0']
- [epy_block_0, clear_input, qtgui_edit_box_msg_0, val]
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_2, '0', blocks_delay_0, '0']
- [virtual_source_3, '0', analog_simple_squelch_cc_0, '0']
- [virtual_source_3_0, '0', channels_selective_fading_model_0, '0']
- [virtual_source_4, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
